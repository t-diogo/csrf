options:
  parameters:
    author: 60383 60556 60841
    generate_options: qt_gui
    id: teste
    output_language: python
    title: LAB1 CSRF - 60383 60556 60841
  states: {}

blocks:
- name: a1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '200e-3'
    stop: '2'
    value: '1'
  states: {}
- name: a2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '200e-3'
    stop: '1'
    value: '0'
  states: {}
- name: a3
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '200e-3'
    stop: '1'
    value: '0'
  states: {}
- name: noise_level
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '5e-3'
    stop: '300e-3'
    value: '100e-3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 768e3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 75e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 75e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 75e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_divide_xx_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_exponentiate_const_cci_0
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '2'
  states: {}
- name: blocks_exponentiate_const_cci_0_0
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: '3'
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: a1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: a2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: a3
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Tomas\Desktop\uni\5th\1st_sem\csrf\lab\github\csrf\lab1\gnu-radio\pedro.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 25e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 25e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alias: Rx signal
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Signal
    name: FFT plot
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label: Relative Gain Rx
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label: Relative Gain Tx
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_snr
  id: qtgui_number_sink
  parameters:
    alias: SNR
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: SNR
    name: SNR(dB)
    type: float
    unit1: dB
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Amplitude Rx
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Amplitude Tx
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: tx_signal
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_rms_xx_1, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_sig_source_x_1_0_0_0, '0', blocks_multiply_xx_0_1, '1']
- [analog_sig_source_x_1_0_1, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_add_xx_1, '0', virtual_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_rms_xx_0, '0']
- [blocks_complex_to_mag_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_divide_xx_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_exponentiate_const_cci_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_exponentiate_const_cci_0_0, '0', blocks_multiply_const_vxx_0_1_1, '0']
- [blocks_float_to_complex_0_0, '0', blocks_exponentiate_const_cci_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_exponentiate_const_cci_0_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_float_to_complex_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_0_1_1, '0', blocks_add_xx_1, '2']
- [blocks_multiply_const_vxx_0_2, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_2, '0', blocks_multiply_xx_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_snr, '0']
- [blocks_rms_xx_0, '0', blocks_divide_xx_1, '0']
- [blocks_rms_xx_1, '0', blocks_divide_xx_1, '1']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_1, '0']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_1, '1']
- [virtual_source_0, '0', blocks_complex_to_float_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
